# Keil uVision project Count 0-255 Led.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8xC51RD+ NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM(0-0x2FF) CLOCK(33000000) MODP2
  output: Count 0-255 Led +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Count 0-255 Led.c
